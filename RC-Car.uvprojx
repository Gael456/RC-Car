# Keil uVision project RC-Car.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RC-Car
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group src
    ./: Motor.c Timer_Interrupt.c UART1.c Command_Parser.c GPIO.c
  group inc
    ./: Motor.h Timer_Interrupt.h UART1.h Command_Parser.h GPIO.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
